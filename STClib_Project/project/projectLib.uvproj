# Keil uVision project projectLib.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: projectLib +hex
  AfterMake: copyfile.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib\inc;..\user;..\lib\inc\mcu;..\lib\inc\sys
  group boot
    ../boot/: boot.a51
  group lib
    ../lib/src/: C51_ADC.C C51_GPIO.C C51_Timer.C C51_EEPROM.C C51_Uart.C
  group hal
    ../hal/: C51_Hardware_Init.C
  group user
    ../user/: user_main.c C51_conf.h
